# Keil uVision project w5500rtos.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: w5500rtos +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\User;.\uCOS-II\Ports;.\uCOS-II\Source;.\BSP\Base;.\BSP\Internet;.\BSP\W5500
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: app.c app_cfg.h includes.h os_cfg.h stm32f10x_it.c
  group uCOS-II/Port
    ./uCOS-II/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uCOS-II/Src
    ./uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group CMSIS
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_tim.c
  group Startup
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group BSP
    ./BSP/Base/: usart.c usart.h
